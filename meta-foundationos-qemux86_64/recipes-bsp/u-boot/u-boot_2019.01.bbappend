require u-boot-foundationos-qemu.inc
